** Full_Wave_Recifier_Inductor_Filter **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:44:29
*

*## Multisim Component R2 ##*
rR2 0 5 1000 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
* !!!BEGIN-INTERACT
*  : increment     ++++f4 ;
*  : setresistance ++++f6 ;
*  0.0             constant  mindval
*  100.0           constant  maxdval
*  0.0             VARIABLE  resistance
*  50.0            VARIABLE  setting
*  0.0             VARIABLE  setfactor
*  0.0             VARIABLE  zeroadj
*  0.0             VARIABLE  tresistance
*  0               VARIABLE  num_stored
*  0.0             VARIABLE  setresval
*  0	           VARIABLE  flag
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*      *flag 0 = if
*      LOAD_FICL_VARIABLES
*      ==>_*num_stored
*      ==>_*num_stored
*      *num_stored 0 > if
*         ==>_*setting
*         ==>_*setresval
*         *setresval tresistance f./ ==>_*setfactor
*         *setresval SET_INSTANCE Resistor ::R R1  resistance
*         tresistance *setresval f.- SET_INSTANCE Resistor ::R R2  resistance
*      endif
*      1 ==>_*flag
*      endif
*      setresistance ==>_*tresistance
*      0.01 *setting f.* ==>_*zeroadj
*      *zeroadj PERCENT SET_ANIMATION_TEXT
*      0.0000001 0.9999999 *zeroadj f.min f.max  ==>_*setfactor
*      *setfactor *tresistance f.* resistance GRADUAL_CHANGE_AT_RUN
*      *setfactor tresistance f.* *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value                       SET_INSTANCE Resistor ::R R1  resistance
*    *tresistance  value f.-       SET_INSTANCE Resistor ::R R2  resistance
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT
xR1 R1_OPEN_1 0 2  PotentiometerR1
.subckt PotentiometerR1 1 2 3
R1 1 2  1e-3
R2 2 3  1e-3
.ends

*## Multisim Component L1 ##*
* !!!BEGIN-INTERACT
*  : increment ++++f4 ;
*  : tinductance ++++f6 ;
*  : coil_resistance  ++++f8 ;
*  0.0         constant mindval
*  100.0       constant maxdval
*  tinductance VARIABLE inductance
*  50.0        VARIABLE setting
*  0.0         VARIABLE setfactor
*  0.0         VARIABLE zeroadj
*  0           VARIABLE num_stored
*  0.0         VARIABLE setcoilval
*  0	       VARIABLE flag
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*     *flag 0 = if
*        LOAD_FICL_VARIABLES
*        ==>_*num_stored
*        ==>_*num_stored
*        *num_stored 0 > if
*           ==>_*setting
*           ==>_*setcoilval
*           *setcoilval tinductance f./ ==>_*setfactor
*           *setcoilval SET_INSTANCE Inductor ::L L1  inductance
*        endif
*      1 ==>_*flag
*      endif
*      0.01 *setting f.* ==>_*zeroadj
*      *zeroadj PERCENT SET_ANIMATION_TEXT
*      0.01 *setting f.* tinductance f.* inductance GRADUAL_CHANGE_AT_RUN
*      0.000001 0.999999 *zeroadj f.min f.max  ==>_*setfactor
*      *setfactor tinductance f.* SET_INSTANCE Inductor ::L L1  inductance
*      *setfactor tinductance f.* *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value                       SET_INSTANCE Inductor ::L L1  inductance
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
* !!!END-INTERACT
xL1 2 5 VariableInductorL1
.subckt VariableInductorL1 1 2
L1 1 2  5e-3
.ends

*## Multisim Instrument XSC1 ##*

*## Multisim Component D2 ##*
dD2 4 5 1N4001__DIODE__1

*## Multisim Component D1 ##*
dD1 8 5 1N4001__DIODE__1

*## Multisim Component T2 ##*
xT2 1 0 8 0 4 TEMPLATE_1P2S_TAP_TMODEL__TRANSFORMER__1__1

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 325.26911926 50 0 0 0)

.subckt TEMPLATE_1P2S_TAP_TMODEL__TRANSFORMER__1__1   p1pos p1neg s1pos s12mid s2neg
.param np1=32
.param ns1=1
.param ns2=1
.param Lmag=50u
.param Lleakage=10u
.param Rcoil=0.8

***Primary coil 1
Llp1 p1pos p1mid {Lleakage}
Rp1 p1mid p1coil {Rcoil}
G1 p1coil p1neg value={-1/np1*(ns1*I(Es1)+ns2*I(Es2))}

***Secondary coil 1
Lls1 s1pos s1mid {Lleakage}
Rs1 s1mid s1coil {Rcoil}
Es1 s1coil s12mid value={V(p1pos,p1neg)*ns1/np1}

***Secondary coil 2
Lls2 s12mid s2mid {Lleakage}
Rs2 s2mid s2coil {Rcoil}
Es2 s2coil s2neg value={V(p1pos,p1neg)*ns2/np1}

***Core
Lmag p1coil p1neg {Lmag}

  .ends

.MODEL 1N4001__DIODE__1 d (
+IS=3.19824e-08 RS=0.0428551 N=2 EG=0.784216
+XTI=0.504749 BV=53 IBV=0.0001 CJO=4.67862e-11
+VJ=0.4 M=0.469632 FC=0.5 TT=8.86839e-06
+KF=0 AF=1 )
