** LC_Oscillator **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:42:59
*

*## Multisim Component L1 ##*
lL1 1 3 2e-005

*## Multisim Component C4 ##*
cC4 0 3 1e-008

*## Multisim Component C3 ##*
cC3 1 0 1e-008

*## Multisim Component Q1 ##*
qQ1 3 1 2 QBF240__BJT_NPN__1

*## Multisim Instrument XSC1 ##*

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 12

*## Multisim Component C2 ##*
cC2 2 0 0.000122

*## Multisim Component C1 ##*
cC1 3 5 1e-006

*## Multisim Component R4 ##*
rR4 VCC 3 1500 vresR4
.model vresR4 r(  )

*## Multisim Component R3 ##*
rR3 2 0 2500 vresR3
.model vresR3 r(  )

*## Multisim Component R2 ##*
rR2 VCC 1 30280 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 1 0 28500 vresR1
.model vresR1 r(  )

.MODEL QBF240__BJT_NPN__1 NPN(
+ IS = 6.686E-16
+ NF = 0.9934
+ ISE = 1.84E-15
+ NE = 1.632
+ BF = 135
+ IKF = 0.06
+ VAF = 116.5
+ NR = 1.003
+ ISC = 9.197E-15
+ NC = 1.133
+ BR = 6.24
+ IKR = 0.05
+ VAR = 5.34
+ RB = 1
+ IRB = 0.01
+ RBM = 0.5
+ RE = 0.6
+ RC = 1.8
+ XTB = 0
+ EG = 1.11
+ XTI = 3
+ CJE = 2.288E-12
+ VJE = 0.55
+ MJE = 0.2019
+ TF = 2.911E-10
+ XTF = 54.94
+ VTF = 1.762
+ ITF = 0.1644
+ PTF = 0
+ CJC = 9.099E-13
+ VJC = 0.1927
+ MJC = 0.1982
+ XCJC = 0.811
+ TR = 1E-32
+ CJS = 0
+ VJS = 0.75
+ MJS = 0.333
+ FC = 0.8999)
