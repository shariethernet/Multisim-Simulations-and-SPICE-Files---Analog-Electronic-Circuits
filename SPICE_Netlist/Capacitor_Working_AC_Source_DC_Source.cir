** Capacitor_Working_AC_Source_DC_Source **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:40:44
*

*## Multisim Instrument XMM1 ##*
XMM1 1 2 XXMM1_590727600

*## Multisim Component V2 ##*
vV2 1 3 dc 3 ac 0 0
+           distof1 0 0
+           distof2 0 0

*## Multisim Instrument XSC1 ##*

*## Multisim Component R1 ##*
rR1 2 0 1000 vresR1
.model vresR1 r(  )

*## Multisim Component C1 ##*
cC1 1 2 0.0001

*## Multisim Component V1 ##*
vV1 3 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 1 50 0 0 0)

.subckt XXMM1_590727600 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends
