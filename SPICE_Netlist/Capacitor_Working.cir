** Capacitor_Working **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:39:45
*

*## Multisim Instrument XSC1 ##*

*## Multisim Instrument XMM1 ##*
XMM1 2 3 XXMM1_147453080

*## Multisim Component R1 ##*
rR1 3 0 1000 vresR1
.model vresR1 r(  )

*## Multisim Component C1 ##*
cC1 2 3 0.005

*## Multisim Component V2 ##*
* !!!BEGIN-INTERACT
*  : increment  ++++f8 ;
*  : tmaxvalue  ++++f4 ;
*  : tminvalue  ++++f6 ;
*  0.0          constant mindval
*  100.0        constant maxdval
*  tmaxvalue    VARIABLE maxvalue
*  tminvalue    VARIABLE minvalue
*  50.0         VARIABLE setting
*  0            VARIABLE num_stored
*  0.0          VARIABLE setsourceval
*  0.0          VARIABLE zeroadj
*  0.0          VARIABLE setfactor
*  0            VARIABLE flag
*  0.0          VARIABLE outputval
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*     *flag 0 = if
*        LOAD_FICL_VARIABLES
*        ==>_*num_stored
*        ==>_*num_stored
*        *num_stored 0 > if
*           ==>_*setting
*           ==>_*setsourceval
*          *setsourceval SET_INSTANCE vsource ::V V1  dc
*        endif
*      1 ==>_*flag
*      endif
*      0.01 *setting f.* ==>_*setfactor
*      tmaxvalue tminvalue f.- *setfactor f.* tminvalue f.+ ==>_*outputval
*      *outputval VALUE 0 SET_ANIMATION_TEXT_BYID
*      *outputval maxvalue GRADUAL_CHANGE_AT_RUN
*      *outputval *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value SET_INSTANCE vsource ::V V1  dc
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
* !!!END-INTERACT
xV2 2 1 VariableDCVoltageV2
.subckt VariableDCVoltageV2 1 2
V1 1 2  10
.ends

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 1 50 0 0 0)

.subckt XXMM1_147453080 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends
