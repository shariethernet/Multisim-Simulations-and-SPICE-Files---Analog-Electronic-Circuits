** Bistable_Multivibrator **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:38:29
*

*## Multisim Instrument XSC2 ##*

*## Multisim Instrument XFG1 ##*
XFG1 8 XFG1_OPEN_2 5 XXFG1_481861376

*## Multisim Instrument XSC1 ##*

*## Multisim Component V1 ##*
vV1 3 0 dc 10 ac 0 0
+           distof1 0 0
+           distof2 0 0

*## Multisim Component R7 ##*
rR7 6 0 470 vresR7
.model vresR7 r(  )

*## Multisim Component R6 ##*
rR6 4 0 39000 vresR6
.model vresR6 r(  )

*## Multisim Component R5 ##*
rR5 5 0 39000 vresR5
.model vresR5 r(  )

*## Multisim Component R4 ##*
rR4 5 2 42000 vresR4
.model vresR4 r(  )

*## Multisim Component R3 ##*
rR3 1 4 42000 vresR3
.model vresR3 r(  )

*## Multisim Component R2 ##*
rR2 3 2 3300 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 3 1 3300 vresR1
.model vresR1 r(  )

*## Multisim Component C2 ##*
cC2 2 5 4.7e-005

*## Multisim Component C1 ##*
cC1 1 4 4.7e-005

*## Multisim Component Q2 ##*
qQ2 2 4 6 BC107BP__BJT_NPN__1

*## Multisim Component Q1 ##*
qQ1 1 5 6 BC107BP__BJT_NPN__1

.subckt XXFG1_481861376 1 2 3
vfgen_src_positive 3 2 dc 0.000000e+000 ac 1.000000000000000000e+001 pulse(-1.000000000000000000e+001 1.000000000000000000e+001 0 1.000000000000000000e-008 1.000000000000000000e-008 1.799990000000000200e-003 2.000000000000000000e-003)
vfgen_src_negative 2 1 dc 0.000000e+000 ac 1.000000000000000000e+001 pulse(-1.000000000000000000e+001 1.000000000000000000e+001 0 1.000000000000000000e-008 1.000000000000000000e-008 1.799990000000000200e-003 2.000000000000000000e-003)
.ends

.MODEL BC107BP__BJT_NPN__1 NPN IS =1.8E-14 ISE=5.0E-14 NF =.9955 NE =1.46 BF =400 BR =35.5
+IKF=.14 IKR=.03 ISC=1.72E-13 NC =1.27 NR =1.005 RB =.56 RE =.6 RC =.25 VAF=80
+VAR=12.5 CJE=13E-12 TF =.64E-9 CJC=4E-12 TR =50.72E-9 VJC=.54 MJC=.33
