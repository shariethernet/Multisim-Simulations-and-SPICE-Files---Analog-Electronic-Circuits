** Capacitor_Working_AC_Source_Alone **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:40:15
*

*## Multisim Instrument XSC1 ##*

*## Multisim Component R1 ##*
rR1 2 0 1000 vresR1
.model vresR1 r(  )

*## Multisim Component C1 ##*
cC1 1 2 0.0001

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 1 50 0 0 0)
