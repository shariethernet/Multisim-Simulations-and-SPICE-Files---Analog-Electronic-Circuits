** RMS_Value_Check_Sine_Wave **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:43:19
*

*## Multisim Instrument XMM1 ##*
XMM1 2 0 XXMM1_645069752

*## Multisim Component R1 ##*
rR1 1 2 1000 vresR1
.model vresR1 r(  )

*## Multisim Instrument XMM2 ##*
XMM2 1 0 XXMM2_645069752

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 10.139 50 0 0 0)

.subckt XXMM1_645069752 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e-009
.ends

.subckt XXMM2_645069752 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends
