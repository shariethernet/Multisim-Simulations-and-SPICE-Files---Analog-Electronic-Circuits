** RC_Phase_Shift_Oscilaltor **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:43:09
*

*## Multisim Instrument XSC1 ##*

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 9

*## Multisim Component C5 ##*
cC5 6 7 1e-008

*## Multisim Component C4 ##*
cC4 4 6 1e-008

*## Multisim Component C3 ##*
cC3 3 4 1e-008

*## Multisim Component C2 ##*
cC2 2 0 0.0001

*## Multisim Component C1 ##*
cC1 3 5 1e-006

*## Multisim Component R7 ##*
* !!!BEGIN-INTERACT
*  : increment     ++++f4 ;
*  : setresistance ++++f6 ;
*  0.0             constant  mindval
*  100.0           constant  maxdval
*  0.0             VARIABLE  resistance
*  50.0            VARIABLE  setting
*  0.0             VARIABLE  setfactor
*  0.0             VARIABLE  zeroadj
*  0.0             VARIABLE  tresistance
*  0               VARIABLE  num_stored
*  0.0             VARIABLE  setresval
*  0	           VARIABLE  flag
*
*  :MAP_KEYBOARD_INPUT ++++k1 1 ++++K1  -1 ;
*
*  : UPDATE_SETTINGS
*      *flag 0 = if
*      LOAD_FICL_VARIABLES
*      ==>_*num_stored
*      ==>_*num_stored
*      *num_stored 0 > if
*         ==>_*setting
*         ==>_*setresval
*         *setresval tresistance f./ ==>_*setfactor
*         *setresval SET_INSTANCE Resistor ::R R1  resistance
*         tresistance *setresval f.- SET_INSTANCE Resistor ::R R2  resistance
*      endif
*      1 ==>_*flag
*      endif
*      setresistance ==>_*tresistance
*      0.01 *setting f.* ==>_*zeroadj
*      *zeroadj PERCENT SET_ANIMATION_TEXT
*      0.0000001 0.9999999 *zeroadj f.min f.max  ==>_*setfactor
*      *setfactor *tresistance f.* resistance GRADUAL_CHANGE_AT_RUN
*      *setfactor tresistance f.* *setting 2 0
*      STORE_FICL_VARIABLES
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*    value                       SET_INSTANCE Resistor ::R R1  resistance
*    *tresistance  value f.-       SET_INSTANCE Resistor ::R R2  resistance
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state (float) increment f.* *setting  f.+  ==>_*setting
*     mindval maxdval *setting f.min f.max ==>_*setting
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*
*  : INIT_SLIDER
*      maxdval mindval 3 IMOUSE_SET
*  ;
*
*  : ON_IMOUSE_EVENT locals| eType fValue |
*    eType 9 = if
*      -1
*      fValue ==>_*setting
*    else
*      0
*    endif
*    UPDATE_SETTINGS
*  ;
*
*  : GET_INTERACT_VALUE locals| eType |
*      eType 0 = if
*        *setting
*      else eType 1 = if
*        mindval
*      else eType 2 = if
*        maxdval
*      else eType 3 = if
*        increment
*      else
*        0
*      endif endif endif endif
*  ;
*
*  : SET_INTERACT_VALUE locals| eType fValue |
*      eType 0 = if
*        fValue ==>_*setting
*      endif
*      UPDATE_SETTINGS
*  ;
*
*  :ON_USER_UPDATE
*    UPDATE_SETTINGS
*    INIT_SLIDER
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT
xR7 R7_OPEN_1 1 7  PotentiometerR7
.subckt PotentiometerR7 1 2 3
R1 1 2  1e-3
R2 2 3  1e-3
.ends

*## Multisim Component R6 ##*
rR6 6 0 4700 vresR6
.model vresR6 r(  )

*## Multisim Component R5 ##*
rR5 4 0 4700 vresR5
.model vresR5 r(  )

*## Multisim Component R4 ##*
rR4 VCC 3 1500 vresR4
.model vresR4 r(  )

*## Multisim Component R3 ##*
rR3 2 0 3000 vresR3
.model vresR3 r(  )

*## Multisim Component R2 ##*
rR2 VCC 1 52000 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 1 0 37000 vresR1
.model vresR1 r(  )

*## Multisim Component Q1 ##*
qQ1 3 1 2 BC107BP__BJT_NPN__1

.MODEL BC107BP__BJT_NPN__1 NPN IS =1.8E-14 ISE=5.0E-14 NF =.9955 NE =1.46 BF =400 BR =35.5
+IKF=.14 IKR=.03 ISC=1.72E-13 NC =1.27 NR =1.005 RB =.56 RE =.6 RC =.25 VAF=80
+VAR=12.5 CJE=13E-12 TF =.64E-9 CJC=4E-12 TR =50.72E-9 VJC=.54 MJC=.33
