** Astable_Multivibrator **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:37:52
*

*## Multisim Instrument XSC1 ##*

*## Multisim Component C2 ##*
cC2 1 5 1e-008

*## Multisim Component C1 ##*
cC1 4 2 1e-008

*## Multisim Component R4 ##*
rR4 3 1 4700 vresR4
.model vresR4 r(  )

*## Multisim Component R3 ##*
rR3 3 2 4700 vresR3
.model vresR3 r(  )

*## Multisim Component R2 ##*
rR2 3 4 47000 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 3 5 47000 vresR1
.model vresR1 r(  )

*## Multisim Component Q2 ##*
qQ2 2 5 0 BC107BP__BJT_NPN__1

*## Multisim Component Q1 ##*
qQ1 1 4 0 BC107BP__BJT_NPN__1

*## Multisim Component V1 ##*
vV1 3 0 dc 9 ac 0 0
+           distof1 0 0
+           distof2 0 0

.MODEL BC107BP__BJT_NPN__1 NPN IS =1.8E-14 ISE=5.0E-14 NF =.9955 NE =1.46 BF =400 BR =35.5
+IKF=.14 IKR=.03 ISC=1.72E-13 NC =1.27 NR =1.005 RB =.56 RE =.6 RC =.25 VAF=80
+VAR=12.5 CJE=13E-12 TF =.64E-9 CJC=4E-12 TR =50.72E-9 VJC=.54 MJC=.33
