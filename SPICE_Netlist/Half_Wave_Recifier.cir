** Half_Wave_Recifier **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:42:08
*

*## Multisim Instrument XMM6 ##*
XMM6 1 0 XXMM6_630187680

*## Multisim Instrument XMM5 ##*
XMM5 2 0 XXMM5_630187680

*## Multisim Instrument XMM4 ##*
XMM4 5 0 XXMM4_630187680

*## Multisim Instrument XMM3 ##*
XMM3 2 3 XXMM3_630187680

*## Multisim Instrument XSC1 ##*

*## Multisim Instrument XMM2 ##*
XMM2 4 5 XXMM2_630187680

*## Multisim Component RL ##*
rRL 5 0 1000 vresRL
.model vresRL r(  )

*## Multisim Component D1 ##*
dD1 2 3 1N4001__DIODE__1

*## Multisim Instrument XMM1 ##*
XMM1 3 4 XXMM1_630187680

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 325.26911926 50 0 0 0)

*## Multisim Component T1 ##*
xT1 1 0 2 0 Tran_T1
.subckt Tran_T1 p1pos p1neg s1pos s1neg
***Primary coil 1

G1 p1pos p1neg value={-1/31*(1*I(Es1))}

***Secondary coil 1

Es1 s1pos s1neg value={V(p1pos,p1neg)*1/31}

.ends

.subckt XXMM6_630187680 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt XXMM5_630187680 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt XXMM4_630187680 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt XXMM3_630187680 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt XXMM2_630187680 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e-009
.ends

.MODEL 1N4001__DIODE__1 d (
+IS=3.19824e-08 RS=0.0428551 N=2 EG=0.784216
+XTI=0.504749 BV=53 IBV=0.0001 CJO=4.67862e-11
+VJ=0.4 M=0.469632 FC=0.5 TT=8.86839e-06
+KF=0 AF=1 )

.subckt XXMM1_630187680 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e-009
.ends
