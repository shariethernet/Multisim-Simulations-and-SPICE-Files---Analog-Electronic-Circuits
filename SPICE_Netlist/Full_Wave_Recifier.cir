** Full_Wave_Recifier **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:41:07
*

*## Multisim Instrument XMM6 ##*
XMM6 5 2 XXMM6_601321400

*## Multisim Instrument XMM2 ##*
XMM2 2 3 XXMM2_601321400

*## Multisim Instrument XSC1 ##*

*## Multisim Instrument XMM7 ##*
XMM7 4 5 XXMM7_601321400

*## Multisim Instrument XMM4 ##*
XMM4 4 0 XXMM4_601321400

*## Multisim Instrument XMM1 ##*
XMM1 8 0 XXMM1_601321400

*## Multisim Instrument XMM5 ##*
XMM5 5 0 XXMM5_601321400

*## Multisim Instrument XMM3 ##*
XMM3 8 5 XXMM3_601321400

*## Multisim Component D2 ##*
dD2 4 5 1N4001__DIODE__1

*## Multisim Component D1 ##*
dD1 8 5 1N4001__DIODE__1

*## Multisim Component T2 ##*
xT2 1 0 8 0 4 TEMPLATE_1P2S_TAP_TMODEL__TRANSFORMER__1__1

*## Multisim Component RL ##*
rRL 3 0 1000 vresRL
.model vresRL r(  )

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 325.26911926 50 0 0 0)

.subckt TEMPLATE_1P2S_TAP_TMODEL__TRANSFORMER__1__1   p1pos p1neg s1pos s12mid s2neg
.param np1=31
.param ns1=1
.param ns2=1
.param Lmag=50u
.param Lleakage=10u
.param Rcoil=0.8

***Primary coil 1
Llp1 p1pos p1mid {Lleakage}
Rp1 p1mid p1coil {Rcoil}
G1 p1coil p1neg value={-1/np1*(ns1*I(Es1)+ns2*I(Es2))}

***Secondary coil 1
Lls1 s1pos s1mid {Lleakage}
Rs1 s1mid s1coil {Rcoil}
Es1 s1coil s12mid value={V(p1pos,p1neg)*ns1/np1}

***Secondary coil 2
Lls2 s12mid s2mid {Lleakage}
Rs2 s2mid s2coil {Rcoil}
Es2 s2coil s2neg value={V(p1pos,p1neg)*ns2/np1}

***Core
Lmag p1coil p1neg {Lmag}

   .ends

.subckt XXMM2_601321400 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e-009
.ends

.subckt XXMM1_601321400 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt XXMM5_601321400 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt XXMM3_601321400 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.MODEL 1N4001__DIODE__1 d (
+IS=3.19824e-08 RS=0.0428551 N=2 EG=0.784216
+XTI=0.504749 BV=53 IBV=0.0001 CJO=4.67862e-11
+VJ=0.4 M=0.469632 FC=0.5 TT=8.86839e-06
+KF=0 AF=1 )

.subckt XXMM6_601321400 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e-009
.ends
.subckt XXMM7_601321400 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends
.subckt XXMM4_601321400 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends
