** Half_Wave_Recifier_Power **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:42:31
*

*## Multisim Instrument XWM1 ##*
XWM1 2 6 XXWM1_647972176

*## Multisim Instrument XMM6 ##*
XMM6 1 0 XXMM6_647972176

*## Multisim Instrument XMM5 ##*
XMM5 2 0 XXMM5_647972176

*## Multisim Instrument XMM4 ##*
XMM4 7 0 XXMM4_647972176

*## Multisim Instrument XMM3 ##*
XMM3 6 3 XXMM3_647972176

*## Multisim Instrument XMM2 ##*
XMM2 4 7 XXMM2_647972176

*## Multisim Component RL ##*
rRL 7 0 1000 vresRL
.model vresRL r(  )

*## Multisim Component D1 ##*
dD1 6 3 1N4001__DIODE__1

*## Multisim Instrument XMM1 ##*
XMM1 3 4 XXMM1_647972176

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 325.26911926 50 0 0 0)

*## Multisim Component T1 ##*
xT1 1 0 2 0 Tran_T1
.subckt Tran_T1 p1pos p1neg s1pos s1neg
***Primary coil 1

G1 p1pos p1neg value={-1/32*(1*I(Es1))}

***Secondary coil 1

Es1 s1pos s1neg value={V(p1pos,p1neg)*1/32}

.ends

.subckt XXWM1_647972176 3 4
Vamp 3 4 0
.ends

.subckt XXMM6_647972176 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt XXMM5_647972176 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt XXMM4_647972176 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt XXMM3_647972176 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt XXMM2_647972176 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e-009
.ends

.MODEL 1N4001__DIODE__1 d (
+IS=3.19824e-08 RS=0.0428551 N=2 EG=0.784216
+XTI=0.504749 BV=53 IBV=0.0001 CJO=4.67862e-11
+VJ=0.4 M=0.469632 FC=0.5 TT=8.86839e-06
+KF=0 AF=1 )

.subckt XXMM1_647972176 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e-009
.ends
