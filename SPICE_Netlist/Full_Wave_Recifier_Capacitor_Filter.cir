** Full_Wave_Recifier_Capacitor_Filter **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Welcome
* Tue, Jul 06, 2021 22:44:21
*

*## Multisim Instrument XMM1 ##*
XMM1 2 0 XXMM1_671692600

*## Multisim Component S1 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS1 2 5   SwitchS1

.subckt SwitchS1 1 2
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
.MODEL NC_contact ISWITCH (Ion=0.05 Ioff=0.025 Ron=1e-8 Roff=1e30)
.ENDS

*## Multisim Component C1 ##*
cC1 0 5 4.7e-005

*## Multisim Component RL ##*
rRL 2 0 1000 vresRL
.model vresRL r(  )

*## Multisim Instrument XSC1 ##*

*## Multisim Component D2 ##*
dD2 4 2 1N4001__DIODE__1

*## Multisim Component D1 ##*
dD1 3 2 1N4001__DIODE__1

*## Multisim Component T2 ##*
xT2 1 0 3 0 4 TEMPLATE_1P2S_TAP_TMODEL__TRANSFORMER__1__1

*## Multisim Component V1 ##*
vV1 1 0 dc 0 ac 1 0
+      distof1 0 0
+      distof2 0 0
+      sin(0 325.26911926 50 0 0 0)

.subckt XXMM1_671692600 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.subckt TEMPLATE_1P2S_TAP_TMODEL__TRANSFORMER__1__1   p1pos p1neg s1pos s12mid s2neg
.param np1=32
.param ns1=1
.param ns2=1
.param Lmag=50u
.param Lleakage=10u
.param Rcoil=0.8

***Primary coil 1
Llp1 p1pos p1mid {Lleakage}
Rp1 p1mid p1coil {Rcoil}
G1 p1coil p1neg value={-1/np1*(ns1*I(Es1)+ns2*I(Es2))}

***Secondary coil 1
Lls1 s1pos s1mid {Lleakage}
Rs1 s1mid s1coil {Rcoil}
Es1 s1coil s12mid value={V(p1pos,p1neg)*ns1/np1}

***Secondary coil 2
Lls2 s12mid s2mid {Lleakage}
Rs2 s2mid s2coil {Rcoil}
Es2 s2coil s2neg value={V(p1pos,p1neg)*ns2/np1}

***Core
Lmag p1coil p1neg {Lmag}

  .ends

.MODEL 1N4001__DIODE__1 d (
+IS=3.19824e-08 RS=0.0428551 N=2 EG=0.784216
+XTI=0.504749 BV=53 IBV=0.0001 CJO=4.67862e-11
+VJ=0.4 M=0.469632 FC=0.5 TT=8.86839e-06
+KF=0 AF=1 )
